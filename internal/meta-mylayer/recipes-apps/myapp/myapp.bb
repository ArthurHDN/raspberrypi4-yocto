SUMMARY = "My application OCI image"

LICENSE = "CLOSED"
